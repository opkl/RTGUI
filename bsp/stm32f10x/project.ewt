<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Applications</name>
    <file>
      <name>$PROJ_DIR$\applications\application.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\applications\canapp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\applications\startup.c</name>
    </file>
  </group>
  <group>
    <name>CORTEX-M3</name>
    <file>
      <name>$PROJ_DIR$\..\..\libcpu\arm\common\backtrace.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\libcpu\arm\cortex-m3\context_iar.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\libcpu\arm\cortex-m3\cpuport.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\libcpu\arm\common\div0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\libcpu\arm\common\showmem.c</name>
    </file>
  </group>
  <group>
    <name>DeviceDrivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\can\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\src\completion.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\src\dataqueue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\misc\pin.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\src\pipe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\src\portal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\src\ringbuffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\serial\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\drivers\src\workqueue.c</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <file>
      <name>$PROJ_DIR$\drivers\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\bxcan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\usart.c</name>
    </file>
  </group>
  <group>
    <name>finsh</name>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_compiler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_error.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_heap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_node.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_ops.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_parser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_token.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_var.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\finsh_vm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\shell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\finsh\symbol.c</name>
    </file>
  </group>
  <group>
    <name>GUIEngine</name>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\asc12font.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\asc16font.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\blit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\box.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\color.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\container.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\dc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\dc_blend.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\dc_buffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\dc_client.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\dc_hw.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\dc_rotozoom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\dc_trans.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\filerw.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\font.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\font_bmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\font_fnt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\font_freetype.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\font_hz_bmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\font_hz_file.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\hz12font.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\hz16font.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\image.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\image_bmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\image_hdc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\image_jpg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\image_png.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\image_xpm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\matrix.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\mouse.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\region.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\rtgui_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\rtgui_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\rtgui_object.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\rtgui_system.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\server.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\title.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\topwin.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\widget.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\components\gui\src\window.c</name>
    </file>
  </group>
  <group>
    <name>Kernel</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\components.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\device.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\idle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\ipc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\irq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\kservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\mempool.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\object.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\scheduler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\thread.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\timer.c</name>
    </file>
  </group>
  <group>
    <name>STM32_StdPeriph</name>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\cmsis\cm3\devicesupport\st\stm32f10x\startup\iar\startup_stm32f10x_hd.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\stm32f10x_stdperiph_driver\src\stm32f10x_wwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libraries\cmsis\cm3\devicesupport\st\stm32f10x\system_stm32f10x.c</name>
    </file>
  </group>
</project>


